const Hwi = scripting.addModule("/ti/sysbios/family/arm/m3/Hwi");
