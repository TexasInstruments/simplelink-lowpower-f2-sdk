const Hwi = scripting.addModule("/ti/sysbios/family/arm/v8m/Hwi");