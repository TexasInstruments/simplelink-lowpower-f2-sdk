<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/rfEchoRx_LP_EM_CC1312PSIP_tirtos7_iar.ewp</path>
    </project>
    <batchBuild/>
</workspace>