<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/sha2hash_LP_CC2652R7_freertos_iar.ewp</path>
    </project>
    <batchBuild/>
</workspace>