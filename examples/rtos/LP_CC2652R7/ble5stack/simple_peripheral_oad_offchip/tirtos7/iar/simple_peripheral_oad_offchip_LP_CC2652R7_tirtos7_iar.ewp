# IAR project simple_peripheral_oad_offchip_LP_CC2652R7_tirtos7_iar.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
configuration Debug (ARM, debug)
  as the first configuration, except:
  group (top)
    ./: simple_peripheral_oad_offchip_LP_CC2652R7_tirtos7_iar.ipcf SysConfig_Generated_Files.ipcf
